# Keil uVision project iSO-STM32.uvprojx, settings and files
target 智能拐杖 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\nmea_decode\include;..\..\User\gps;..\..\User\SysTick;..\..\User\gprs;..\..\User\angle;..\..\User\Wave;..\..\User\UltrasonicWave;..\..\User\key;..\..\User\GPRS;..\..\User\debug
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
  group sys
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/usart/: bsp_usart.c
    ../../User/debug/: debug.c
  group nmea_decode
    ../../User/nmea_decode/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c tok.c time.c sentence.c
  group DOC
    ../../Doc/: readme.txt
  group UltrasonicWave
    ../../User/UltrasonicWave/: UltrasonicWave.c bsp_delay.c waveConfig.c
  group angle
    ../../User/angle/: bsp_angle.c
  group key
    ../../User/key/: bsp_exti.c
  group GPS
    ../../User/gps/: gps.c
  group GPRS
    ../../User/GPRS/: gprs.c timer.c
    ../../User/usart/: bsp_usart4.c
software components: CMSIS:CORE 4.1.0
